Commit message: added non-zero rotation to joint origin

File: urdf/test_setup.urdf (robot description, URDF)
Before this commit: robot floating_joints_test, 3 links, 2 joints
Joints:
- joint world_to_link_A: origin xyz=1 0 0 rpy=0 0 0 -> xyz=1 0 0 rpy=1.570796 0 0
